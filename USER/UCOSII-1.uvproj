# Keil uVision project UCOSII-1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UCOSII-1 +hex
  c flags: Optim=4
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\FLASH;..\HARDWARE\GSM;..\HARDWARE\lcd_rl;..\HARDWARE\MAX6675;..\HARDWARE\pressure;..\HARDWARE\TIMER;..\HARDWARE\USART;..\HARDWARE\user_GPRS;..\HARDWARE\SysTick;..\HARDWARE\radix;..\HARDWARE\NANOPB;..\HARDWARE\SPIFS;..\HARDWARE\SPI_Flash;..\HARDWARE\MAX31855;..\HARDWARE\shh;..\HARDWARE\Filter;..\HARDWARE\GPS;..\FATFS\exfuns;..\FATFS\src;..\MALLOC;..\HARDWARE\SD;..\HARDWARE\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/GSM/: gsm.c
    ../HARDWARE/pressure/: pressure.c
    ../HARDWARE/radix/: radix.c
    ../HARDWARE/SysTick/: SysTick.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/user_GPRS/: gprs_jiankong.c gprs_sh.c
    ../HARDWARE/SPI_Flash/: spi_flash.c
    ../HARDWARE/MAX31855/: MAX31855.c
    ../HARDWARE/shh/: shh.c hexstring.c
    ../HARDWARE/Filter/: filter.c
    ../HARDWARE/lcd_rl/: proto.c lcd_rl.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SD/: MMC_SD.C
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group FATFFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group MALLOC
    ../MALLOC/: malloc.c
